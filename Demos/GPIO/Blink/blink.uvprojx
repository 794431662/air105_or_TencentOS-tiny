# Keil uVision project blink.uvprojx, settings and files
target air105_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: TencentOS +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./@L.bin Objects/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Drivers\CMSIS\Device\Air105\Include;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\Air105_StdPeriph_Driver\inc;.\Library\inc;.\User;.\Tencen_OS\arch\arm\arm-v7m\common\include;.\Tencen_OS\arch\arm\arm-v7m\cortex-m4\armcc;.\Tencen_OS\kernel\core\include;.\Tencen_OS\osal\cmsis_os;.\Tencen_OS
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0xffffff
  memory RVCT9: RAM 0x20000000 size 0x80000
  group STARTUP
    ../../../Drivers/CMSIS/Device/Air105/Source/ARM/: startup_air105.s
  group CMSIS
    ../../../Drivers/CMSIS/Device/Air105/Source/: system_air105.c
  group StdPeriphLib
    ../../../Drivers/Air105_StdPeriph_Driver/src/: air105_adc.c air105_cache.c air105_crc.c air105_dac.c air105_dcmi.c air105_dma.c air105_exti.c air105_gpio.c air105_hspim.c air105_i2c.c air105_kcu.c air105_lcdi.c air105_otp.c air105_qspi.c air105_rtc.c air105_spi.c air105_sysctrl.c air105_timer.c air105_trng.c air105_uart.c air105_wdt.c misc.c
  group Library
    ./Library/src/: delay.c sysc.c usart.c
  group User
    ./User/: air105_it.c main.c
    ./Tencen_OS/: TOS_CONFIG.h
  group tos/arch
    ./Tencen_OS/arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ./Tencen_OS/arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/kernel
    ./Tencen_OS/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/osal
    ./Tencen_OS/osal/cmsis_os/: cmsis_os.c
